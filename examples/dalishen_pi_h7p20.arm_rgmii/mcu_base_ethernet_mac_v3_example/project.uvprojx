# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: HME_MCU +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: .\HME_MCU\inc;.\Task
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group startup
    ./HME_MCU/src/startup/ARM/: startup_HME_MCU.s
  group include
    ./HME_MCU/inc/: BasicDataType.h hme_conf.h hme_dma.h hme_gpio.h hme_i2c.h hme_includes.h hme_it.h HME_MCU.h hme_retarget.h hme_spi.h hme_spiflash.h hme_timer.h hme_uart.h hme_wdt.h sys_reg.h system_hme.h UARTMan.h
  group source
    ./HME_MCU/src/: hme_dma.c hme_gpio.c hme_i2c.c hme_it.c hme_spi.c hme_spiflash.c hme_timer.c hme_uart.c hme_wdt.c sys_reg.c system_hme.c
  group task
    ./Task/: dma_task.c dma_task.h gpio_task.c gpio_task.h i2c_task.c i2c_task.h intr_task.c intr_task.h isp_task.c isp_task.h sleep_task.c sleep_task.h spi_slave_task.c spi_slave_task.h spi_task.c spi_task.h timer_task.c timer_task.h uart_task.c uart_task.h wdt_task.c wdt_task.h
  group user
    ./: main.c
    ./HME_MCU/src/: UART.c
software components: CMSIS:CORE 5.6.0
