# Repository vllogic/dalishen_pi_h7p20 (continued)

## KiCad design hardware/dalishen_pi_h7p20/dalishen_pi_h7p20.kicad_pcb

Parts:
C4, C24, C38, C41, C44, C68: 10uF; C_0402_1005Metric
C5, C6, C7, C8, C9, C10, C11, C17, C18, C19, C20, C21, C22, C23, C42, C43, C45, C54, C56, C61, C62, C63, C64, C65, C74: 0.1uF; C_0402_1005Metric
C16, C46, C70, C71, C72, C73, C75, C76, C77: 1uF; C_0402_1005Metric
C69: 1uF,50V; C_0603_1608Metric
D1: LED_RED; LED_0603_1608Metric
D2: LED_BLUE; LED_0603_1608Metric
D3: LED_GREEN; LED_0603_1608Metric
D4: LED_YELLOW; LED_0603_1608Metric
D8: 1N5819(S4); D_SOD-323_BAT60
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask2mm
J1: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical_SMD
J5: OLED_I2C_128x64; PinSocket_1x04_P2.54mm_Vertical
J6: NC; PinHeader_1x03_P2.54mm_Horizontal
J7: OV5640; Hirose_FH12-24S-0.5SH_1x24-1MP_P0.50mm_Horizontal
J9: D500C930SV0; Hirose_FH12-40S-0.5SH_1x40-1MP_P0.50mm_Horizontal
JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
L1: 10uH; L_NR3015
R8, R14: 470; R_0402_1005Metric
R9, R10, R11, R24: 33; R_0402_1005Metric
R15, R19: 10k,1%; R_0402_1005Metric
R18, R20, R21, R22, R61, R68, R69: 5.1k; R_0402_1005Metric
R55, R56, R57: 2.49k; R_0402_1005Metric
R63, R80, R81, R82: 10k; R_0402_1005Metric
R64, R65: 10,1%; R_0402_1005Metric
SW1, SW2, SW4, SW5: SW_Push; SW-3x6mm_Hxx_SMD
SW3: SW_DIP_x03; SW_DIP_SPSTx03_Slide_6.7x9.18mm_W8.61mm_P2.54mm_LowProfile
TP1, TP2: TestPoint; PinHeader_1x01_P1.00mm_Vertical
U3: H7P20N0L128-M3H1; LQFP-128_14x14mm_P0.4mm_pad
U4: SY7201ABC; SOT-23-6
U5: XC6206-2.8; SOT-23
U7: P25Q64SH-SSH-IR; SOIC-8_P1.27mm_Common
U8: XC6206-1.5; SOT-23

Connections:
/AVDD_2V8: C72.2, C74.2, J7.2, J7.21, R68.2, R69.2, U5.2 (VOUT)
/B1_IO_MSEL0_122: R20.2, R55.2, U3.122 (IO10_MSEL0_1)
/B1_IO_MSEL1_124: R18.2, R56.2, U3.124 (IO4_MSEL1_1)
/B1_IO_MSEL2_125: R15.2, R57.2, U3.125 (IO2_MSEL2_1)
/B2_IO_CDONE_105: R19.2, U3.105 (IO26_CDONE_2)
/B9_IO2N: J1.9, R14.2, U3.51 (IO2N_9)
/B9_IO2P: J1.7, R8.2, U3.52 (IO2P_9)
/B9_IO4N: J1.3, R9.2, U3.54 (IO4N_9)
/B9_IO4P: J1.1, R11.2, U3.55 (IO4P_PCLK_9)
/B9_IO6N: J7.3, U3.56 (IO6N_9)
/B9_IO6P: J7.5, U3.57 (IO6P_9)
/B9_IO9N: J7.7, U3.60 (IO9N_9)
/B9_IO9P: J7.9, U3.61 (IO9P_PCLK_9)
/B9_IO12N: J7.11, U3.63 (IO12N_9)
/B9_IO12P: J7.13, U3.64 (IO12P_9)
/B10_IO2N: J9.23, U3.37 (IO2N_10)
/B10_IO2P: J9.22, U3.38 (IO2P_10)
/B10_IO4N: J9.20, U3.40 (IO4N_10)
/B10_IO4P: J9.19, U3.41 (IO4P_PCLK_10)
/B10_IO6N: J9.17, U3.42 (IO6N_10)
/B10_IO6P: J9.16, U3.43 (IO6P_10)
/B10_IO9N: J9.14, U3.46 (IO9N_10)
/B10_IO9P: J9.13, U3.47 (IO9P_PCLK_10)
/B10_IO12N: J9.11, U3.49 (IO12N_10)
/B10_IO12P: J9.10, U3.50 (IO12P_10)
/CRST_N: C46.2, JP9.1 (A), R61.2, U3.114 (CRSTN)
/DVDD_1V5: C76.2, J7.15, U8.2 (VOUT)
/FPGA_ETHA_25M: U3.82 (IO3_3); also elsewhere on the board
/FPGA_ETHA_MDC: U3.81 (IO24_4); also elsewhere on the board
/FPGA_ETHA_MDIO: U3.73 (IO12_PCLK_4); also elsewhere on the board
/FPGA_ETHA_RST_B: U3.117 (IO16_GCLK_1); also elsewhere on the board
/FPGA_ETHA_RXCK: U3.74 (IO13_GCLK_4); also elsewhere on the board
/FPGA_ETHA_RXCTL: U3.75 (IO15_4); also elsewhere on the board
/FPGA_ETHA_RXD0: U3.76 (IO16_4); also elsewhere on the board
/FPGA_ETHA_RXD1: U3.77 (IO19_4); also elsewhere on the board
/FPGA_ETHA_RXD2: U3.78 (IO20_4); also elsewhere on the board
/FPGA_ETHA_RXD3: U3.80 (IO23_4); also elsewhere on the board
/FPGA_ETHA_TXCK: U3.65 (IO1_4); also elsewhere on the board
/FPGA_ETHA_TXCTL: U3.66 (IO2_4); also elsewhere on the board
/FPGA_ETHA_TXD0: U3.68 (IO7_4); also elsewhere on the board
/FPGA_ETHA_TXD1: U3.69 (IO8_4); also elsewhere on the board
/FPGA_ETHA_TXD2: U3.71 (IO9_4); also elsewhere on the board
/FPGA_ETHA_TXD3: U3.72 (IO10_4); also elsewhere on the board
/FPGA_FLASH_CLK: U3.116 (IO18_PCCLK_1), U7.6 (CLK)
/FPGA_FLASH_CS: R80.2, U3.118 (IO12_CSN_1), U7.1 (~CS)
/FPGA_FLASH_MISO: U3.115 (IO19_MISO1_1), U7.2 (DO(IO1))
/FPGA_FLASH_MOSI: U3.119 (IO11_MOSI0_1), U7.5 (DI(IO0))
/FPGA_RX: JP7.1 (A), U3.108 (IO24_GCLK_1)
/FPGA_TCK: JP5.1 (A), U3.112 (IO21_TCK_1)
/FPGA_TDI: JP3.1 (A), U3.113 (IO20_TDI_1)
/FPGA_TDO: JP6.1 (A), U3.109 (IO23_TDO_1)
/FPGA_TMS: JP4.1 (A), U3.110 (IO22_TMS_1)
/FPGA_TX: JP8.1 (A), U3.106 (IO25_GCLK_2)
/KEY0: SW1.1, U3.126 (IO3_8)
/KEY1: SW4.1, U3.104 (IO27_GCLK_2)
/KEY2: SW5.1, U3.102 (IO33_MISO3_2)
/LEDA: C69.2, D8.1 (K), J9.6, J9.7, U4.5 (OVP)
/LEDK: J9.2, J9.3, R64.1, R65.1, U4.4 (FB)
/LED_PWM: R63.1, U3.8 (IO17_8), U4.2 (EN/PWM)
/OV_MCLK: J7.12, R11.1
/OV_PWDN: J7.17, R9.1
/OV/TP_SCL: J5.3, J7.20, J9.37, R68.1, U3.101 (IO34_MISO2_2)
/OV/TP_SDA: J5.4, J7.22, J9.36, R69.1, U3.99 (IO24_3)
/TP_INT: J9.35, U3.127 (IO4_8)
/USB334x_CLK: U3.92 (IO13_GCLK_3); also elsewhere on the board
/USB334x_D0: U3.86 (IO7_3); also elsewhere on the board
/USB334x_D1: U3.89 (IO9_3); also elsewhere on the board
/USB334x_D2: U3.90 (IO10_3); also elsewhere on the board
/USB334x_D3: U3.96 (IO20_3); also elsewhere on the board
/USB334x_D4: U3.95 (IO19_3); also elsewhere on the board
/USB334x_D5: U3.94 (IO18_3); also elsewhere on the board
/USB334x_D6: U3.93 (IO17_3); also elsewhere on the board
/USB334x_D7: U3.91 (IO12_PCLK_3); also elsewhere on the board
/USB334x_DIR: U3.83 (IO4_3); also elsewhere on the board
/USB334x_NXT: U3.85 (IO6_3); also elsewhere on the board
/USB334x_SP1/USB334x_26M: R24.2; also elsewhere on the board
/USB334x_SP1_CLK: U3.5 (IO12_GCLK_8); also elsewhere on the board
/USB334x_SP1_D0: U3.3 (IO10_8); also elsewhere on the board
/USB334x_SP1_D1: U3.2 (IO7_8); also elsewhere on the board
/USB334x_SP1_D2: U3.1 (IO6_8); also elsewhere on the board
/USB334x_SP1_D3: U3.13 (IO21_8); also elsewhere on the board
/USB334x_SP1_D4: U3.11 (IO20_8); also elsewhere on the board
/USB334x_SP1_D5: U3.10 (IO19_8); also elsewhere on the board
/USB334x_SP1_D6: U3.9 (IO18_8); also elsewhere on the board
/USB334x_SP1_D7: U3.6 (IO13_PCLK_8); also elsewhere on the board
/USB334x_SP1_DIR: U3.14 (IO22_8); also elsewhere on the board
/USB334x_SP1_NXT: U3.4 (IO11_8); also elsewhere on the board
/USB334x_SP1_STP: U3.15 (IO1_7); also elsewhere on the board
/USB334x_SP2/USB334x_26M: R10.2; also elsewhere on the board
/USB334x_SP2_CLK: U3.22 (IO12_GCLK_7); also elsewhere on the board
/USB334x_SP2_D0: U3.20 (IO9_7); also elsewhere on the board
/USB334x_SP2_D1: U3.19 (IO6_7); also elsewhere on the board
/USB334x_SP2_D2: U3.18 (IO5_7); also elsewhere on the board
/USB334x_SP2_D3: U3.29 (IO18_7); also elsewhere on the board
/USB334x_SP2_D4: U3.28 (IO17_7); also elsewhere on the board
/USB334x_SP2_D5: U3.25 (IO16_7); also elsewhere on the board
/USB334x_SP2_D6: U3.24 (IO15_7); also elsewhere on the board
/USB334x_SP2_D7: U3.23 (IO13_PCLK_7); also elsewhere on the board
/USB334x_SP2_DIR: U3.31 (IO21_7); also elsewhere on the board
/USB334x_SP2_NXT: U3.21 (IO10_7); also elsewhere on the board
/USB334x_SP2_STP: U3.32 (IO22_7); also elsewhere on the board
/USB334x_SPx_26M: R10.1, R24.1, U3.16 (IO2_7)
/USB334x_STP: U3.98 (IO23_3); also elsewhere on the board
/VCCAUX: C19.2, C20.2, C22.2, C23.2, C24.2, U3.27 (VDDAUX), U3.44 (VDDAUX), U3.58 (VDDAUX), U3.87 (VDDAUX), U3.120 (VDDAUX); also elsewhere on the board
/VCC_3V3: C16.2, C42.2, C43.2, C61.2, C62.2, C63.2, C64.2, C65.2, C70.2, C71.2, C73.2, C75.2, J1.8, J1.10, J5.2, J9.25, J9.26, J9.27, J9.28, J9.39, R21.2, R22.2, R61.1, R80.1, R81.1, R82.1, SW3.4, SW3.5, SW3.6, U3.12 (VDDIO_8), U3.17 (VDDIO_7), U3.30 (VDDIO_7), U3.67 (VDDIO_4), U3.79 (VDDIO_4), U3.84 (VDDIO_3), U3.97 (VDDIO_3), U3.103 (VDDIO_2), U3.111 (VDDIO_1), U3.123 (VDDIO_1), U3.128 (VDDIO_8), U5.3 (VIN), U7.8 (VCC), U8.3 (VIN); also elsewhere on the board
/VCC_5V: C68.2, J1.2, J1.4, JP2.1 (A), L1.1, U4.1 (IN); also elsewhere on the board
/VDDIO_1V8: C21.2, C44.2, C45.2, C54.2, C56.2, C77.2, J7.14, J7.19, U3.33 (VDDIO_18), U3.35 (VDDIO_18), U3.39 (VDDIO_10), U3.48 (VDDIO_10), U3.53 (VDDIO_9), U3.62 (VDDIO_9); also elsewhere on the board
/VDD_CORE: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C17.2, C18.2, C38.2, C41.2, U3.7 (VDD_CORE), U3.26 (VDD_CORE), U3.36 (VDD_CORE), U3.45 (VDD_CORE), U3.59 (VDD_CORE), U3.70 (VDD_CORE), U3.88 (VDD_CORE), U3.100 (VDD_CORE), U3.121 (VDD_CORE); also elsewhere on the board
/YT8531C/FPGA_ETHA_CLKOUT: TP2.1; also elsewhere on the board
/vllinkmodule/5V: JP2.2 (B); also elsewhere on the board
/vllinkmodule/GPIOA0: JP5.2 (B); also elsewhere on the board
/vllinkmodule/GPIOA1: JP4.2 (B); also elsewhere on the board
/vllinkmodule/GPIOA2: JP6.2 (B); also elsewhere on the board
/vllinkmodule/GPIOA3: JP3.2 (B); also elsewhere on the board
/vllinkmodule/GPIOA5: SW2.2; also elsewhere on the board
/vllinkmodule/GPIOA6: JP8.2 (B); also elsewhere on the board
/vllinkmodule/GPIOA7: JP7.2 (B); also elsewhere on the board
/vllinkmodule/GPIOB2: JP9.2 (B); also elsewhere on the board
GND: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C38.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C54.1, C56.1, C61.1, C62.1, C63.1, C64.1, C65.1, C68.1, C69.1, C70.1, C71.1, C72.1, C73.1, C74.1, C75.1, C76.1, C77.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J1.5, J1.6, J5.1, J6.2, J7.10, J7.23, J9.9, J9.12, J9.15, J9.18, J9.21, J9.24, J9.29, J9.32, J9.33, J9.38, R63.2, R64.2, R65.2, SW1.2, SW2.1, SW4.2, SW5.2, U3.34 (GND), U3.107 (MSC), U3.129 (GND), U4.3 (GND), U5.1 (VSS), U7.4 (GND), U7.9 (EP), U8.1 (VSS); also elsewhere on the board
unnamed: D1.2 (A), R15.1
unnamed: D2.2 (A), R18.1
unnamed: D3.2 (A), R19.1
unnamed: D4.2 (A), R20.1
unnamed: D8.2 (A), L1.2, U4.6 (LX)
unnamed: J6.1, R8.1
unnamed: J6.3, R14.1
unnamed: J9.30, TP1.1
unnamed: J9.31, R21.1
unnamed: J9.34, R22.1
unnamed: R55.1, SW3.1
unnamed: R56.1, SW3.2
unnamed: R57.1, SW3.3
unnamed: R81.2, U7.3 (IO2)
unnamed: R82.2, U7.7 (IO3)

Notes on the sheet:
OV5640 500万像素 MIPI接口
NC LEDK LEDK NC NC LEDA LEDA NC GND D0P D0N GND D1P D1N GND CLKP CLKN GND D2P D2N GND D3P D3N GND IOVCC IOVCC VCC VCC GND TD LCD_RESET GND GND TP_RES TP_INT TP_SDA TP_SCL GND TP_VDD NC
NC1 AGND SIO-D AVDD SIO-C RESET NC PWDN NC DVDD DOVDD MDP1 MCLK MDN1 DGND MCP NC MCN NC MDP0 NC MDN0 AF-VDD NC
1.27mm 2x7P 双排 MIPI扩展口
5.0寸1280x720触摸屏 MIPI接口
OV/TP_SCL：可置0或高阻 OV/TP_SDA：可置0或高阻

Parts:
C47, C57, C58: 10uF; C_0402_1005Metric
C48, C51, C52, C53, C55, C59, C60, C66, C67: 0.1uF; C_0402_1005Metric
C78: 0R; C_0402_1005Metric
C79: NC; C_0402_1005Metric
J10: RJ45_HR911130A
L2: 4.7uH,MPL2012S4R7MHT; L_0805_2012Metric
R6: 0; R_0402_1005Metric
R38, R39, R45: 2.49k; R_0402_1005Metric
R40, R42, R43, R46, R47, R48, R49, R50, R54, R62: 5.1k; R_0402_1005Metric
R41: 4.7k; R_0402_1005Metric
R44: 10k,1%; R_0402_1005Metric
R51, R52, R53: NC; R_0402_1005Metric
R70, R71, R72, R73, R74, R75, R83, R84, R85, R86, R87, R91: 33; R_0402_1005Metric
U1: YT8531C; QFN-40-1EP_5x5mm_P0.4mm_EP3.6x3.6mm
Y2: NC; OSC_3225

Connections:
/FPGA_ETHA_25M: R6.1; also elsewhere on the board
/FPGA_ETHA_MDC: U1.13 (MDC); also elsewhere on the board
/FPGA_ETHA_MDIO: R44.2, U1.14 (MDIO); also elsewhere on the board
/FPGA_ETHA_RST_B: R41.2, U1.12 (RESET_N); also elsewhere on the board
/FPGA_ETHA_RXCK: R70.1; also elsewhere on the board
/FPGA_ETHA_RXCTL: R71.1; also elsewhere on the board
/FPGA_ETHA_RXD0: R49.2, R52.1, R72.1; also elsewhere on the board
/FPGA_ETHA_RXD1: R50.2, R53.1, R73.1; also elsewhere on the board
/FPGA_ETHA_RXD2: R51.2, R54.1, R74.1; also elsewhere on the board
/FPGA_ETHA_RXD3: R75.1; also elsewhere on the board
/FPGA_ETHA_TXCK: R83.1; also elsewhere on the board
/FPGA_ETHA_TXCTL: R84.1; also elsewhere on the board
/FPGA_ETHA_TXD0: R85.1; also elsewhere on the board
/FPGA_ETHA_TXD1: R86.1; also elsewhere on the board
/FPGA_ETHA_TXD2: R87.1; also elsewhere on the board
/FPGA_ETHA_TXD3: R91.1; also elsewhere on the board
/VCC_3V3: C55.2, C57.2, C58.2, C59.2, C60.2, R40.1, R41.1, R44.1, R48.1, R49.1, R50.1, R51.1, U1.11 (AVDD33), U1.28 (DVCC_RGMII), U1.29 (DVDD33), U1.40 (AVDD33); also elsewhere on the board
/YT8531C/ETHA_1V1: C47.2, C48.2, C51.2, C52.2, C53.2, L2.2, U1.3 (AVDDL), U1.8 (AVDDL), U1.21 (DVDDL), U1.38 (AVDDL)
/YT8531C/ETHA_LED1: J10.14, R42.1, U1.33 (LED1/CFG_LDO0)
/YT8531C/ETHA_LED2: J10.11, R43.1, U1.34 (LED2/CFG_LDO1)
/YT8531C/ETHA_TD0N: J10.P3 (TD1-), U1.2 (TRXN0)
/YT8531C/ETHA_TD0P: J10.P2 (TD1+), U1.1 (TRXP0)
/YT8531C/ETHA_TD1N: J10.P7 (TD2-), U1.5 (TRXN1)
/YT8531C/ETHA_TD1P: J10.P4 (TD2+), U1.4 (TRXP1)
/YT8531C/ETHA_TD2N: J10.P6 (TD3-), U1.7 (TRXN2)
/YT8531C/ETHA_TD2P: J10.P5 (TD3+), U1.6 (TRXP2)
/YT8531C/ETHA_TD3N: J10.P9 (TD4-), U1.10 (TRXN3)
/YT8531C/ETHA_TD3P: J10.P8 (TD4+), U1.9 (TRXP3)
/YT8531C/FPGA_ETHA_CLKOUT: U1.35 (CLKOUT); also elsewhere on the board
GND: C47.1, C48.1, C51.1, C52.1, C53.1, C55.1, C57.1, C58.1, C59.1, C60.1, C66.1, C67.1, C78.1, C79.1, J10.SH, R38.2, R39.2, R42.2, R43.2, R45.2, R46.2, R47.2, R52.2, R53.2, R54.2, R62.2, U1.41 (GND), Y2.2, Y2.4; also elsewhere on the board
unnamed: C66.2, J10.P1 (CT)
unnamed: C67.2, J10.P10 (GND), R62.1
unnamed: J10.12, R39.1
unnamed: J10.13, R38.1
unnamed: R40.2, U1.32 (LED0/CFG_EXT)
unnamed: R45.1, U1.39 (RBIAS)
unnamed: L2.1, U1.30 (REG_O)
unnamed: R72.2, U1.25 (RXD0/RXDLY)
unnamed: R73.2, U1.24 (RXD1/TXDLY)
unnamed: R74.2, U1.23 (RXD2/PLLIFF)
unnamed: R48.2, R75.2, U1.22 (RXD3/PHYAD0)
unnamed: R46.1, R70.2, U1.27 (RX_CLK/PHYAD1)
unnamed: R47.1, R71.2, U1.26 (RX_CTL/PHYAD2)
unnamed: R85.2, U1.18 (TXD0)
unnamed: R86.2, U1.17 (TXD1)
unnamed: R87.2, U1.16 (TXD2)
unnamed: R91.2, U1.15 (TXD3)
unnamed: R83.2, U1.20 (TX_CLK)
unnamed: R84.2, U1.19 (TX_CTL)
unnamed: C78.2, U1.36 (XTAL_I), Y2.1
unnamed: C79.2, R6.2, U1.37 (XTAL_O), Y2.3

Parts:
2x5_2.54.1001: NC; IDC-Header_2x05_P2.54mm_Vertical
AE1001: Antenna_Shield; Texas_SWRA117D_2.4GHz_Left
C1002: NC; C_0402_1005Metric
C1003, C1006: 4.3pF; C_0402_1005Metric
C1005, C1009: 10uF; C_0402_1005Metric
C1007, C1008: 1uF; C_0402_1005Metric
C1010: 10uF; C_0402_6mil
C1011: NC; C_0402_6mil
C1012, C1013: 1uF; C_0402_6mil
F1: SMD0805B100TFT; Fuse_0805_2012Metric
J1001: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
L1001, L1003: 0R; L_0402_1005Metric
L1004: 4.7uH,MPL2012S4R7MHT; L_0805_2012Metric
R1001, R1002: 5.1k; R_0402_1005Metric
R1003: 47k; R_0402_1005Metric
TP1001, TP1002, TP1003, TP1004, TP1005, TP1006, TP1007: TestPoint; TestPoint_Pad_D0.75mm
U1001: AIC8800FC; QFN-36-1EP_4x4mm_P0.35mm_EP2.5x2.5mm
U1002: P25Q80H/P25Q64H/P25Q128HA; USON-8-1EP_3x2mm_P0.5mm_EP1.6x02mm
Y1001: 26M, 10PPM; OSC_2016

Connections:
/vllinkmodule/3.3V: C1005.1, C1012.1, TP1002.1, U1001.24 (VIO), U1001.32 (AVDD33), U1001.33 (AVDD33_PA)
/vllinkmodule/5V: C1010.1, C1011.1, F1.1, R1003.2, TP1003.1, U1001.27 (VBAT); also elsewhere on the board
/vllinkmodule/FLS_CLK: U1001.22 (FLS_CLK), U1002.6 (CLK)
/vllinkmodule/FLS_CS: U1001.18 (FLS_CS), U1002.1 (~CS)
/vllinkmodule/FLS_IO0: U1001.23 (FLS_IO0), U1002.5 (DI(IO0))
/vllinkmodule/FLS_IO1: U1001.19 (FLS_IO1), U1002.2 (DO(IO1))
/vllinkmodule/FLS_IO2: U1001.20 (FLS_IO2), U1002.3 (IO2)
/vllinkmodule/FLS_IO3: U1001.21 (FLS_IO3), U1002.7 (IO3)
/vllinkmodule/GPIOA0: 2x5_2.54.1001.1, U1001.3 (GPIOA0); also elsewhere on the board
/vllinkmodule/GPIOA1: 2x5_2.54.1001.5, U1001.4 (GPIOA1); also elsewhere on the board
/vllinkmodule/GPIOA2: 2x5_2.54.1001.3, U1001.5 (GPIOA2); also elsewhere on the board
/vllinkmodule/GPIOA3: 2x5_2.54.1001.9, U1001.6 (GPIOA3); also elsewhere on the board
/vllinkmodule/GPIOA4: U1001.7 (GPIOA4)
/vllinkmodule/GPIOA5: U1001.8 (GPIOA5); also elsewhere on the board
/vllinkmodule/GPIOA6: U1001.9 (GPIOA6); also elsewhere on the board
/vllinkmodule/GPIOA7: U1001.2 (GPIOA7); also elsewhere on the board
/vllinkmodule/GPIOA8: TP1004.1, U1001.30 (GPIOA8)
/vllinkmodule/GPIOA9: TP1005.1, U1001.34 (GPIOA9)
/vllinkmodule/GPIOB0: TP1006.1, U1001.14 (GPIOB0)
/vllinkmodule/GPIOB1: TP1007.1, U1001.15 (GPIOB1)
/vllinkmodule/GPIOB2: 2x5_2.54.1001.8, U1001.26 (GPIOB2); also elsewhere on the board
/vllinkmodule/GPIOB3: U1001.13 (GPIOB3)
/vllinkmodule/POWER_KEY: R1003.1, U1001.35 (POWER_KEY)
/vllinkmodule/USB_D+: J1001.A6 (D+), J1001.B6 (D+), U1001.17 (USB_DP)
/vllinkmodule/USB_D-: J1001.A7 (D-), J1001.B7 (D-), U1001.16 (USB_DM)
/vllinkmodule/V_FLS: C1008.1, U1001.29 (V_FLS), U1002.8 (VCC)
GND: 2x5_2.54.1001.2, 2x5_2.54.1001.10, AE1001.2 (Shield), C1002.2, C1003.1, C1005.2, C1006.1, C1007.1, C1008.2, C1009.2, C1010.2, C1011.2, C1012.2, C1013.2, J1001.A1 (GND), J1001.A8 (SBU1), J1001.A12 (GND), J1001.B1 (GND), J1001.B8 (SBU2), J1001.B12 (GND), J1001.S1 (SHIELD), L1001.1, R1001.1, R1002.1, TP1001.1, U1001.37 (GND), U1002.4 (GND), U1002.9 (EP), Y1001.2, Y1001.4; also elsewhere on the board
unnamed: AE1001.1 (A), C1002.1, L1003.1
unnamed: F1.2, J1001.A4 (VBUS), J1001.A9 (VBUS), J1001.B4 (VBUS), J1001.B9 (VBUS)
unnamed: J1001.A5 (CC1), R1001.2
unnamed: J1001.B5 (CC2), R1002.2
unnamed: C1007.2, U1001.12 (AVDD18)
unnamed: L1003.2, U1001.36 (RF_ANT)
unnamed: L1001.2, U1001.1 (RF_IND)
unnamed: L1004.1, U1001.28 (SW)
unnamed: C1013.1, U1001.25 (V_CORE)
unnamed: C1009.1, L1004.2, U1001.31 (V_RF)
unnamed: C1003.2, U1001.10 (XTAL1), Y1001.1
unnamed: C1006.2, U1001.11 (XTAL2), Y1001.3

Parts:
C25, C28, C35: 220pF; C_0402_1005Metric
C26, C27, C29, C30, C31, C32, C33, C36, C37: 10uF; C_0402_1005Metric
C34, C39, C40: 1uF; C_0402_1005Metric
L3, L4, L5: 1.5uH; L_NR2520xx
R5, R32: 10k,1%; R_0402_1005Metric
R29, R31, R35: 20k,1%; R_0402_1005Metric
R30, R34, R36: 33k,1%; R_0402_1005Metric
R33: 150k,1%; R_0402_1005Metric
U6: EA3036C; QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm
U9: CJ3439KDW; SOT-363_SC-70-6

Connections:
/ET3036C_CJ3439KDW/EA3036_EN2: C40.2, R35.1, U6.8 (EN2)
/ET3036C_CJ3439KDW/EA3036_EN3: C39.2, R36.1, U6.18 (EN3)
/VCCAUX: C28.1, C29.2, C30.2, L4.1, R5.2, R31.2, U9.4 (S2); also elsewhere on the board
/VCC_3V3: C35.2, C36.2, C37.2, L5.1, R33.1, U9.2 (G1); also elsewhere on the board
/VCC_5V: C31.2, C32.2, C33.2, C34.2, R35.2, R36.2, U6.7 (VIN2), U6.9 (EN1), U6.10 (VIN1), U6.16 (VCC), U6.19 (VIN3); also elsewhere on the board
/VDDIO_1V8: U9.3 (D2); also elsewhere on the board
/VDD_CORE: C25.1, C26.2, C27.2, L3.2, R29.2; also elsewhere on the board
GND: C26.1, C27.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C36.1, C37.1, C39.1, C40.1, R30.1, R32.1, R34.2, U6.1 (GND3), U6.4 (GND2), U6.5 (GND2), U6.12 (GND1), U6.13 (GND1), U6.15 (AGND), U6.17 (AGND), U6.21 (EPAD), U9.1 (S1); also elsewhere on the board
unnamed: C25.2, R29.1, R30.2, U6.14 (FB1)
unnamed: C28.2, R31.1, R32.2, U6.3 (FB2)
unnamed: C35.1, R33.2, R34.1, U6.2 (FB3)
unnamed: L3.1, U6.11 (LX1)
unnamed: L4.2, U6.6 (LX2)
unnamed: L5.2, U6.20 (LX3)
unnamed: R5.1, U9.5 (G2), U9.6 (D1)
