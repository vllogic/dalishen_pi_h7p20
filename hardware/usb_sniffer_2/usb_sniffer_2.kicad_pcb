# Repository vllogic/dalishen_pi_h7p20

File readme.md:

[English](readme.md) | [简体中文](readme.zh-CN.md)

# I. Introduction

**Dalishen Pi** is a truly open-source FPGA development board. From the very
beginning, the project has been developed in the open using Git, publishing
both hardware and software materials, in the hope that like-minded people can
learn FPGA application development together and grow into full-stack
electronics engineers.

At a time when ultra-cheap microcontrollers are everywhere, Dalishen Pi
deliberately avoids simple peripherals and focuses on three application areas:
USB 2.0 High-Speed, RGMII Gigabit Ethernet, and MIPI<sup>1</sup>. With the
onboard programmer and the USB Sniffer function, the board can be used both as
a development platform and as a tool.

* [1] The hardware interface is reserved; a demo from the FPGA vendor is required.

# II. Key Features

* Programmer and development board in one. After cutting the JTAG-related
  solder jumpers, the programmer can be used standalone. It supports the latest
  version of the Hercules Micro Fuxi toolchain and most of its devices.
* Supports a top-to-top board-to-board connection to a ~CNY 20
  `EZ-USB CY7A68013A` board. After loading the
  `examples/dalishen_pi_h7p20.ataradov.usb_sniffer` firmware, it becomes a
  USB 2.0 protocol analyzer.

# III. Onboard Devices

### [Hercules Micro H7P20N0L128-M3H1](https://hercules-micro.com/index/index/core?id=16)
* 20K logic cells
* LUT6 architecture
* 1152 Kb EMB
* Integrated ARM Cortex-M3 at 268 MHz
* 2304 KB SRAM
* Integrated 128 Mb pSRAM
* LQFP128 package

### [AIC AIC8800FC](https://www.aicsemi.com/)
* Used for the high-speed programmer/debugger
* Reserved external interface, 3.3 V logic level only

### YT8531C
* RGMII Gigabit PHY

### USB3343
* ULPI USB 2.0 High-Speed PHY

# IV. Interfaces

### EZ-USB CY7A68013A board-to-board connector
* Used to connect an EZ-USB CY7A68013A board, about CNY 20
  [purchase link](https://item.taobao.com/item.htm?id=620955124878)

### MIPI DSI 40-pin connector
* Used to connect a 5.0-inch 720x1280 LCD, model `D500C930SV0`, with touch,
  CNY 65 [purchase link](https://item.taobao.com/item.htm?id=707705009617)
* Note: the MIPI interface is currently reserved only and requires future
  development support.

### MIPI CSI 24-pin connector
* Used to connect an OV5640 MIPI camera, part variants `*-23AF`, about CNY 20
  [purchase link](https://item.taobao.com/item.htm?id=816198271497)
* Note: the MIPI interface is currently reserved only and requires future
  development support.

# V. Hardware

* In progress; not yet fabricated or tested.

# VI. Examples

* [Detailed documentation](./examples/readme.md)

# VII. Community

* QQ group: 635683631

# VIII. License

Unless a file or directory contains its own license file or license notice,
the contents of this repository are licensed under the GNU General Public
License v3.0 (GPLv3). See [LICENSE](./LICENSE).

Component licenses:

* `hardware/usb_sniffer_2/`: **GPLv3**. See `hardware/usb_sniffer_2/LICENSE`.
* `examples/usb_sniffer_h7p20.ataradov.usb_sniffer/`: **BSD-3-Clause**.
  See the `LICENSE` file in that directory. Ported from
  [ataradov/usb-sniffer](https://github.com/ataradov/usb-sniffer).
* `examples/dalishen_pi_h7p20.ultraembedded.core_usb_cdc/`: **LGPL-2.1**.
  See the source file headers and `examples/readme.md`.
* Other ports under `examples/` retain their original licenses as listed in
  [`examples/readme.md`](./examples/readme.md).

The USB Sniffer 2 device firmware and host tool are kept in a separate
repository and are licensed under **BSD-3-Clause**:
<https://github.com/vllogic/ataradov.usb-sniffer>

## KiCad design hardware/usb_sniffer_2/usb_sniffer_2.kicad_pcb

File hardware/usb_sniffer_2/readme.md:

___
# English
# I. Introduction
* 
* Hardware design format: KiCad 9.0.6
* The CH32H417 serves as a USB 3.0 forwarder, with a unidirectional communication speed of up to 400MB/s, breaking the speed bottleneck of the 68013.
* 10 pairs of LVDS are broken out via an FFC connector, making it convenient to use as a USB 3.0 + FPGA expansion board.
* Default is PS mode, with reserved SPI FLASH pads. It supports adjustment to AS mode to facilitate secondary development.
# II. Main Components
1. [HME H7P20N0L128-M3H1](https://hercules-micro.com/index/index/core?id=16)
2. [WCH CH32H417WEU6](https://www.wch-ic.com/products/CH32H417.html)
3. [Microchip USB3343-CP-TR](https://www.microchip.com/en-us/product/usb3343)
# III. Schematic
* [Full PDF](./usb_sniffer_2.pdf)

# IV. Software, Firmware and Licenses

This device uses USB PID `1209:6688` when the firmware is running.

* Hardware (KiCad schematic and PCB, this directory): **GPLv3**. See [LICENSE](./LICENSE).
* FX2LP firmware: <https://github.com/vllogic/ataradov.usb-sniffer/tree/main/firmware>
  * License: **BSD-3-Clause**.
  * Build: open-source SDCC compiler. See `firmware/Makefile` in the firmware repository.
* Host tool `usb_sniffer`: <https://github.com/vllogic/ataradov.usb-sniffer/tree/main/software>
  * License: **BSD-3-Clause**.
* FPGA logic: <https://github.com/vllogic/dalishen_pi_h7p20/tree/main/examples/usb_sniffer_h7p20.ataradov.usb_sniffer>
  * License: **BSD-3-Clause** (see the `LICENSE` file in that directory).
  * Toolchain: Hercules Fuxi. Project files: `usb_sniffer.hpr`, `usb_sniffer.aoc`.

The firmware and host tool are a fork of the open-source project
[ataradov/usb-sniffer](https://github.com/ataradov/usb-sniffer). All hardware,
firmware, host software and FPGA logic listed above are open source.

___
# 中文
## 一、简介
* 
* 硬件图纸格式：Kicad 9.0.6
* CH32H417作为USB3.0转发器，单向通信速率可达400MB/S，解除68013的速率瓶颈
* 通过FFC连接器引出10对LVDS，方便作为USB3.0 + FPGA拓展板
* 默认PS模式，预留SPI FLASH焊盘，支持调整为AS模式，方便二次开发
## 二、主要器件
1. [HME H7P20N0L128-M3H1](https://hercules-micro.com/index/index/core?id=16)
2. [WCH CH32H417WEU6](https://www.wch-ic.com/products/CH32H417.html)
3. [Microchip USB3343-CP-TR](https://www.microchip.com/en-us/product/usb3343)
## 三、原理图
* 
* [完整PDF](./usb_sniffer_2.pdf)
___

Parts:
C2, C15, C44: 10uF; C_0402_1005Metric
C4, C11, C55: 1uF; C_0402_1005Metric
C12, C14, C37, C38, C39, C40, C41, C42, C43, C45, C46, C47, C48, C49, C50, C51, C52, C53, C56, C57, C58, C60, C62: 0.1uF; C_0402_1005Metric
D8: LED_RGBA; LED_RGB_Everlight_EASV3015RGBA0_Horizontal
J1: FPGA_JTAG; PinHeader_1x05_P2.54mm_Vertical
J5: FFC-40P-0.5mm; TE_4-1734839-0_1x40-1MP_P0.5mm_Horizontal
J101: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J102: Conn_01x02; PinHeader_1x02_P1.27mm_Vertical
J103: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
JP2, JP101, JP102: Jumper_2_Small_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R2, R9: 4.7k; R_0402_1005Metric
R3, R5, R6, R19, R67: 10k,1%; R_0402_1005Metric
R83, R101, R102, R103, R104, R105: 33; R_0402_1005Metric
TP1, TP2, TP3: TestPoint; TestPoint_Pad_D0.75mm
U6: P25Q64SH-SSH-IR; SOP-8_3.76x4.96mm_P1.27mm
U13: H7P20N0L128-M3H1; LQFP-128_14x14mm_P0.4mm_pad

Connections:
/B1_IO16: J5.8, U13.117 (IO16_GCLK_1)
/B1_IO24: J5.9, U13.108 (IO24_GCLK_1)
/B1_IO25: J5.10, U13.106 (IO25_GCLK_2)
/B1_IO26_CDONE: J5.11, U13.105 (IO26_CDONE_2)
/B1_IO27: J5.12, U13.104 (IO27_GCLK_2)
/B9_IO2N: J5.27, U13.51 (IO2N_9)
/B9_IO2P: J5.28, U13.52 (IO2P_9)
/B9_IO4N: J5.30, U13.54 (IO4N_9)
/B9_IO4P: J5.31, U13.55 (IO4P_PCLK_9)
/B9_IO6N: J5.32, U13.56 (IO6N_9)
/B9_IO6P: J5.33, U13.57 (IO6P_9)
/B9_IO9N: J5.35, U13.60 (IO9N_9)
/B9_IO9P: J5.36, U13.61 (IO9P_PCLK_9)
/B9_IO12N: J5.38, U13.63 (IO12N_9)
/B9_IO12P: J5.39, U13.64 (IO12P_9)
/B10_IO2N: J5.14, U13.37 (IO2N_10)
/B10_IO2P: J5.15, U13.38 (IO2P_10)
/B10_IO4N: J5.17, U13.40 (IO4N_10)
/B10_IO4P: J5.18, U13.41 (IO4P_PCLK_10)
/B10_IO6N: J5.19, U13.42 (IO6N_10)
/B10_IO6P: J5.20, U13.43 (IO6P_10)
/B10_IO9N: J5.22, U13.46 (IO9N_10)
/B10_IO9P: J5.23, U13.47 (IO9P_PCLK_10)
/B10_IO12N: J5.25, U13.49 (IO12N_10)
/B10_IO12P: J5.26, U13.50 (IO12P_10)
/CH32H417_MCO: R83.1; also elsewhere on the board
/CH32_PA5: J101.1; also elsewhere on the board
/CH32_PC0: J101.3; also elsewhere on the board
/FPGA_CLK_IN: R83.2, U13.5 (IO12_GCLK_8)
/FPGA_CRSTN: R67.2, U13.114 (CRSTN); also elsewhere on the board
/FPGA_FLASH_CLK: R105.1, U6.6 (CLK), U13.116 (IO18_PCCLK_1)
/FPGA_FLASH_CS: R5.2, R101.2, U6.1 (~CS), U13.118 (IO12_CSN_1)
/FPGA_FLASH_MISO: R104.1, U6.2 (DO(IO1)), U13.115 (IO19_MISO1_1)
/FPGA_FLASH_MOSI: U6.5 (DI(IO0)), U13.119 (IO11_MOSI0_1)
/FPGA_JTAG_TCK: J1.2, U13.112 (IO21_TCK_1)
/FPGA_JTAG_TDI: J1.3, U13.113 (IO20_TDI_1)
/FPGA_JTAG_TDO: J1.5, U13.109 (IO23_TDO_1)
/FPGA_JTAG_TMS: J1.4, U13.110 (IO22_TMS_1)
/FPGA_OUT_26M: U13.85 (IO6_3); also elsewhere on the board
/LED_B: R9.1, U13.102 (IO33_MISO3_2)
/LED_G: R3.1, U13.101 (IO34_MISO2_2)
/LED_R: R2.1, U13.99 (IO24_3)
/UHSIF_CLK: U13.22 (IO12_GCLK_7); also elsewhere on the board
/UHSIF_D0: U13.20 (IO9_7); also elsewhere on the board
/UHSIF_D1: U13.19 (IO6_7); also elsewhere on the board
/UHSIF_D2: U13.18 (IO5_7); also elsewhere on the board
/UHSIF_D3: U13.16 (IO2_7); also elsewhere on the board
/UHSIF_D4: U13.15 (IO1_7); also elsewhere on the board
/UHSIF_D5: U13.14 (IO22_8); also elsewhere on the board
/UHSIF_D6: U13.13 (IO21_8); also elsewhere on the board
/UHSIF_D7: U13.11 (IO20_8); also elsewhere on the board
/UHSIF_D8: U13.10 (IO19_8); also elsewhere on the board
/UHSIF_D9: U13.9 (IO18_8); also elsewhere on the board
/UHSIF_D10: U13.8 (IO17_8); also elsewhere on the board
/UHSIF_D11: U13.65 (IO1_4); also elsewhere on the board
/UHSIF_D12: U13.66 (IO2_4); also elsewhere on the board
/UHSIF_D13: U13.68 (IO7_4); also elsewhere on the board
/UHSIF_D14: U13.69 (IO8_4); also elsewhere on the board
/UHSIF_D15: U13.71 (IO9_4); also elsewhere on the board
/UHSIF_D16: U13.72 (IO10_4); also elsewhere on the board
/UHSIF_D17: U13.73 (IO12_PCLK_4); also elsewhere on the board
/UHSIF_D18: U13.74 (IO13_GCLK_4); also elsewhere on the board
/UHSIF_D19: U13.75 (IO15_4); also elsewhere on the board
/UHSIF_D20: U13.76 (IO16_4); also elsewhere on the board
/UHSIF_D21: U13.77 (IO19_4); also elsewhere on the board
/UHSIF_D22: U13.78 (IO20_4); also elsewhere on the board
/UHSIF_D23: U13.80 (IO23_4); also elsewhere on the board
/UHSIF_D24: U13.81 (IO24_4); also elsewhere on the board
/UHSIF_D25: U13.126 (IO3_8); also elsewhere on the board
/UHSIF_D26: U13.127 (IO4_8); also elsewhere on the board
/UHSIF_D27: U13.23 (IO13_PCLK_7); also elsewhere on the board
/UHSIF_D28: U13.28 (IO17_7); also elsewhere on the board
/UHSIF_D29: U13.29 (IO18_7); also elsewhere on the board
/UHSIF_D30: U13.31 (IO21_7); also elsewhere on the board
/UHSIF_D31: U13.32 (IO22_7); also elsewhere on the board
/UHSIF_RDNE_SCK: R105.2; also elsewhere on the board
/UHSIF_SEL0: U13.2 (IO7_8); also elsewhere on the board
/UHSIF_SEL1_PC2: J102.2, U13.1 (IO6_8); also elsewhere on the board
/UHSIF_WRNF_CSN: R101.1; also elsewhere on the board
/UHSIF_~AE: U13.3 (IO10_8); also elsewhere on the board
/UHSIF_~AF_MOSI: R104.2; also elsewhere on the board
/UHSIF_~CS: U13.21 (IO10_7); also elsewhere on the board
/UHSIF_~EOP: U13.4 (IO11_8); also elsewhere on the board
/UHSIF_~OE: U13.25 (IO16_7); also elsewhere on the board
/UHSIF_~RD: U13.6 (IO13_PCLK_8); also elsewhere on the board
/UHSIF_~WR: U13.24 (IO15_7); also elsewhere on the board
/USB334x_CLK: U13.92 (IO13_GCLK_3); also elsewhere on the board
/USB334x_D0: U13.94 (IO18_3); also elsewhere on the board
/USB334x_D1: U13.95 (IO19_3); also elsewhere on the board
/USB334x_D2: U13.96 (IO20_3); also elsewhere on the board
/USB334x_D3: U13.98 (IO23_3); also elsewhere on the board
/USB334x_D4: U13.89 (IO9_3); also elsewhere on the board
/USB334x_D5: U13.86 (IO7_3); also elsewhere on the board
/USB334x_D6: U13.82 (IO3_3); also elsewhere on the board
/USB334x_D7: U13.83 (IO4_3); also elsewhere on the board
/USB334x_DIR: U13.91 (IO12_PCLK_3); also elsewhere on the board
/USB334x_NXT: U13.93 (IO17_3); also elsewhere on the board
/USB334x_STP: U13.90 (IO10_3); also elsewhere on the board
/VCCAUX: C44.2, C46.2, C48.2, C50.2, C52.2, U13.27 (VDDAUX), U13.44 (VDDAUX), U13.58 (VDDAUX), U13.87 (VDDAUX), U13.120 (VDDAUX); also elsewhere on the board
/VCC_3V3: C11.2, C56.2, D8.4 (A), J5.4, J5.5, J103.4, R5.1, R6.1, R19.1, TP2.1, U6.8 (VCC), U13.84 (VDDIO_3), U13.97 (VDDIO_3); also elsewhere on the board
/VCC_5V: J5.1, J5.2, J103.1, TP1.1; also elsewhere on the board
/VDDIO_1V8: C4.2, C45.2, C47.2, C49.2, C51.2, C53.2, C55.2, C57.2, C58.2, C60.2, C62.2, JP2.1 (A), JP101.1 (A), JP102.1 (A), R67.1, R102.1, R103.1, TP3.1, U13.12 (VDDIO_8), U13.17 (VDDIO_7), U13.30 (VDDIO_7), U13.33 (VDDIO_18), U13.35 (VDDIO_18), U13.39 (VDDIO_10), U13.48 (VDDIO_10), U13.53 (VDDIO_9), U13.62 (VDDIO_9), U13.67 (VDDIO_4), U13.79 (VDDIO_4), U13.103 (VDDIO_2), U13.107 (MSC), U13.111 (VDDIO_1), U13.123 (VDDIO_1), U13.128 (VDDIO_8); also elsewhere on the board
/VDD_CORE: C2.2, C12.2, C14.2, C15.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, U13.7 (VDD_CORE), U13.26 (VDD_CORE), U13.36 (VDD_CORE), U13.45 (VDD_CORE), U13.59 (VDD_CORE), U13.70 (VDD_CORE), U13.88 (VDD_CORE), U13.100 (VDD_CORE), U13.121 (VDD_CORE); also elsewhere on the board
GND: C2.1, C4.1, C11.1, C12.1, C14.1, C15.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C55.1, C56.1, C57.1, C58.1, C60.1, C62.1, J1.1, J5.7, J5.13, J5.16, J5.21, J5.24, J5.29, J5.34, J5.37, J5.40, J101.2, J102.1, J103.2, J103.3, U6.4 (GND), U6.9 (EP), U13.34 (GND), U13.129 (GND); also elsewhere on the board
unnamed: D8.3 (BK), R9.2
unnamed: D8.2 (GK), R3.2
unnamed: D8.1 (RK), R2.2
unnamed: JP2.2 (B), U13.122 (IO10_MSEL0_1)
unnamed: JP101.2 (B), R103.2, U13.124 (IO4_MSEL1_1)
unnamed: JP102.2 (B), R102.2, U13.125 (IO2_MSEL2_1)
unnamed: R6.2, U6.3 (IO2)
unnamed: R19.2, U6.7 (IO3)

Notes on the sheet:
GND TCK TDI TMS TDO
PS模式，MSEL[2:0]：110

Parts:
C201: 1nF; C_1206_3216Metric
C236, C237, C245: 1uF; C_0402_1005Metric
C241: 0.1uF; C_0402_1005Metric
J200: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_16P
J201: USB_A; USB_AF_SMT
R201: 1M; R_0603_1608Metric
R206: 8.06k,1%; R_0402_1005Metric
R212, R231: 10k,1%; R_0402_1005Metric
R228, R229: 5.1k,1%; R_0402_1005Metric
U208: USB3343; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm

Connections:
/FPGA_OUT_26M: U208.21 (REFCLK/XI); also elsewhere on the board
/USB334x/T_VBUS: J200.A4 (VBUS), J200.A9 (VBUS), J200.B4 (VBUS), J200.B9 (VBUS), J201.1 (VBUS), R212.1
/USB334x/USB20_D_N: J200.A7 (D-), J200.B7 (D-), J201.2 (D-), U208.14 (DM)
/USB334x/USB20_D_P: J200.A6 (D+), J200.B6 (D+), J201.3 (D+), U208.13 (DP)
/USB334x_CLK: U208.2 (CLKOUT); also elsewhere on the board
/USB334x_D0: U208.4 (DATA0); also elsewhere on the board
/USB334x_D1: U208.5 (DATA1); also elsewhere on the board
/USB334x_D2: U208.6 (DATA2); also elsewhere on the board
/USB334x_D3: U208.7 (DATA3); also elsewhere on the board
/USB334x_D4: U208.8 (DATA4); also elsewhere on the board
/USB334x_D5: U208.10 (DATA5); also elsewhere on the board
/USB334x_D6: U208.11 (DATA6); also elsewhere on the board
/USB334x_D7: U208.12 (DATA7); also elsewhere on the board
/USB334x_DIR: U208.1 (DIR); also elsewhere on the board
/USB334x_NXT: U208.3 (NXT); also elsewhere on the board
/USB334x_STP: U208.24 (STP); also elsewhere on the board
/VCC_3V3: C241.2, C245.2, R231.1, U208.9 (VDDIO), U208.16 (VBAT); also elsewhere on the board
GND: C201.2, C236.1, C237.1, C241.1, C245.1, J200.A1 (GND), J200.A8 (SBU1), J200.A12 (GND), J200.B1 (GND), J200.B8 (SBU2), J200.B12 (GND), J201.4 (GND), R201.2, R206.2, R228.2, R229.2, U208.25 (GND); also elsewhere on the board
unnamed: J200.A5 (CC1), R229.1
unnamed: J200.B5 (CC2), R228.1
unnamed: C201.1, J200.S1 (SHIELD), J201.5 (Shield), R201.1
unnamed: C237.2, U208.15 (VDD33), U208.18 (ID)
unnamed: R206.1, U208.19 (RBIAS)
unnamed: R212.2, U208.17 (VBUS)
unnamed: C236.2, U208.23 (VDD18)
unnamed: R231.2, U208.22 (~RESETB)

Parts:
C501, C502, C503, C504, C513, C515: 10uF; C_0402_1005Metric
C505, C507, C511: 220pF; C_0402_1005Metric
C506, C508, C509: 10uF; C_0603_1608Metric
C510, C512, C514: 1uF; C_0402_1005Metric
L501, L502, L503: 1.5uH; L_NR3015
R501: 154k,1%; R_0402_1005Metric
R502, R507, R508: 33k,1%; R_0402_1005Metric
R503, R505: 10k,1%; R_0402_1005Metric
R504, R506, R509: 20k,1%; R_0402_1005Metric
U501: EA3036C; QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm
U502: CJ3439KDW; SOT-363_SC-70-6

Connections:
/ET3036C_CJ3439KDW/EA3036_EN2: C514.2, R506.1, U501.8 (EN2)
/ET3036C_CJ3439KDW/EA3036_EN3: C512.2, R507.1, U501.18 (EN3)
/VCCAUX: C501.2, C503.2, C507.1, L502.1, R504.2, R505.2, U502.4 (S2); also elsewhere on the board
/VCC_3V3: C502.2, C504.2, C505.2, L501.1, R501.1, U502.2 (G1); also elsewhere on the board
/VCC_5V: C506.2, C508.2, C509.2, C510.2, R506.2, R507.2, U501.7 (VIN2), U501.9 (EN1), U501.10 (VIN1), U501.16 (VCC), U501.19 (VIN3); also elsewhere on the board
/VDDIO_1V8: U502.3 (D2); also elsewhere on the board
/VDD_CORE: C511.1, C513.2, C515.2, L503.2, R509.2; also elsewhere on the board
GND: C501.1, C502.1, C503.1, C504.1, C506.1, C508.1, C509.1, C510.1, C512.1, C513.1, C514.1, C515.1, R502.2, R503.1, R508.1, U501.1 (GND3), U501.4 (GND2), U501.5 (GND2), U501.12 (GND1), U501.13 (GND1), U501.15 (AGND), U501.17 (AGND), U501.21 (EPAD), U502.1 (S1); also elsewhere on the board
unnamed: C511.2, R508.2, R509.1, U501.14 (FB1)
unnamed: C507.2, R503.2, R504.1, U501.3 (FB2)
unnamed: C505.1, R501.2, R502.1, U501.2 (FB3)
unnamed: L503.1, U501.11 (LX1)
unnamed: L502.2, U501.6 (LX2)
unnamed: L501.2, U501.20 (LX3)
unnamed: R505.1, U502.5 (G2), U502.6 (D1)

Parts:
C6: 1uF; C_0402_1005Metric
C9, C54, C59, C61, C65, C72, C75, C76, C79, C82, C86: 0.1uF; C_0402_1005Metric
C16, C63, C74, C77, C78: 4.7uF; C_0402_1005Metric
C70, C71: 18pF; C_0402_1005Metric
C73: 1nF; C_1206_3216Metric
C80: 10uF; C_0603_1608Metric
D11: SMF5V0A; D_SMF
FB1: BLM18PG121SN1D; L_0603_1608Metric
J7: USB3_A; USB_3.0_AF
R68: 1M; R_0603_1608Metric
U2: CH32H417WEU6; QFN-68-1EP_8x8mm_P0.4mm_EP5.2x5.2mm
Y1: 25M; OSC_3225

Connections:
/CH32H417_MCO: U2.21 (PB0/ADC8/OP1_P0/CMP_P0); also elsewhere on the board
/CH32_PA5: U2.20 (PA5/ADC5/OP1_O1/DAC2); also elsewhere on the board
/CH32_PC0: U2.15 (PC0/ADC10/HSADC0); also elsewhere on the board
/FPGA_CRSTN: U2.25 (PE15); also elsewhere on the board
/UHSIF_CLK: U2.65 (PF14); also elsewhere on the board
/UHSIF_D0: U2.33 (PD10); also elsewhere on the board
/UHSIF_D1: U2.34 (PD11); also elsewhere on the board
/UHSIF_D2: U2.35 (PD12); also elsewhere on the board
/UHSIF_D3: U2.36 (PD13); also elsewhere on the board
/UHSIF_D4: U2.37 (PD14); also elsewhere on the board
/UHSIF_D5: U2.38 (PD15); also elsewhere on the board
/UHSIF_D6: U2.39 (PF0); also elsewhere on the board
/UHSIF_D7: U2.40 (PF1); also elsewhere on the board
/UHSIF_D8: U2.41 (PF2); also elsewhere on the board
/UHSIF_D9: U2.42 (PC6); also elsewhere on the board
/UHSIF_D10: U2.43 (PC7); also elsewhere on the board
/UHSIF_D11: U2.44 (PC8); also elsewhere on the board
/UHSIF_D12: U2.45 (PC9); also elsewhere on the board
/UHSIF_D13: U2.46 (PA13); also elsewhere on the board
/UHSIF_D14: U2.47 (PA14); also elsewhere on the board
/UHSIF_D15: U2.48 (PA15); also elsewhere on the board
/UHSIF_D16: U2.49 (PC10); also elsewhere on the board
/UHSIF_D17: U2.50 (PC11); also elsewhere on the board
/UHSIF_D18: U2.51 (PC12); also elsewhere on the board
/UHSIF_D19: U2.52 (PD0); also elsewhere on the board
/UHSIF_D20: U2.53 (PD1); also elsewhere on the board
/UHSIF_D21: U2.54 (PD2); also elsewhere on the board
/UHSIF_D22: U2.55 (PD3); also elsewhere on the board
/UHSIF_D23: U2.56 (PD4); also elsewhere on the board
/UHSIF_D24: U2.57 (PD5); also elsewhere on the board
/UHSIF_D25: U2.58 (PD6); also elsewhere on the board
/UHSIF_D26: U2.59 (PD7); also elsewhere on the board
/UHSIF_D27: U2.60 (PF3); also elsewhere on the board
/UHSIF_D28: U2.61 (PF4); also elsewhere on the board
/UHSIF_D29: U2.62 (PF5); also elsewhere on the board
/UHSIF_D30: U2.63 (PE0); also elsewhere on the board
/UHSIF_D31: U2.64 (PE1); also elsewhere on the board
/UHSIF_RDNE_SCK: U2.26 (PB10); also elsewhere on the board
/UHSIF_SEL0: U2.16 (PC1/ADC11/HSADC1); also elsewhere on the board
/UHSIF_SEL1_PC2: U2.17 (PC2/ADC12/HSADC2); also elsewhere on the board
/UHSIF_WRNF_CSN: U2.24 (PE14); also elsewhere on the board
/UHSIF_~AE: U2.22 (PB1/ADC9/OP1_N0/CMP_N0); also elsewhere on the board
/UHSIF_~AF_MOSI: U2.18 (PC3/ADC13/HSADC3); also elsewhere on the board
/UHSIF_~CS: U2.32 (PB14); also elsewhere on the board
/UHSIF_~EOP: U2.23 (PE13); also elsewhere on the board
/UHSIF_~OE: U2.30 (PB12); also elsewhere on the board
/UHSIF_~RD: U2.27 (PB11); also elsewhere on the board
/UHSIF_~WR: U2.31 (PB13); also elsewhere on the board
/VBUS_5V: D11.1 (A1), FB1.1, J7.1 (VBUS)
/VCC_3V3: C6.1, C9.1, C63.1, C65.1, C72.1, C76.1, C78.1, U2.6 (VDD33), U2.12 (VDD33), U2.19 (VDD33A), U2.29 (VDDIO); also elsewhere on the board
/VCC_5V: C80.2, C82.2, FB1.2; also elsewhere on the board
/VDDIO_1V8: C75.1, C77.1, C79.2, U2.28 (VIO18), U2.66 (VIO18); also elsewhere on the board
/ch32h417weu6/USB30_D_N: J7.2 (D-), U2.68 (PB9/USB2DM/SWDIO)
/ch32h417weu6/USB30_D_P: J7.3 (D+), U2.67 (PB8/USB2DP/SWCLK)
/ch32h417weu6/USB30_SSRX_N: J7.5 (SSRX-), U2.5 (SSRXA)
/ch32h417weu6/USB30_SSRX_P: J7.6 (SSRX+), U2.4 (SSRXB)
/ch32h417weu6/USB30_SSTX_N: C54.2, U2.2 (SSTXA)
/ch32h417weu6/USB30_SSTX_P: C59.2, U2.1 (SSTXB)
/ch32h417weu6/VDD12A: C74.1, C86.1, U2.3 (VDD12A)
/ch32h417weu6/VDDK: C16.1, C61.1, U2.7 (VDDK)
/ch32h417weu6/XI: C70.2, U2.13 (XI), Y1.1
/ch32h417weu6/XO: C71.2, U2.14 (XO), Y1.3
/ch32h417weu6/__USB_SSTX_N: C54.1, J7.8 (SSTX-)
/ch32h417weu6/__USB_SSTX_P: C59.1, J7.9 (SSTX+)
GND: C6.2, C9.2, C16.2, C61.2, C63.2, C65.2, C70.1, C71.1, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.1, C80.1, C82.1, C86.2, D11.2 (A2), J7.4 (GND), J7.7 (DRAIN), R68.2, U2.69 (GND), Y1.2, Y1.4; also elsewhere on the board
unnamed: C73.1, J7.10 (SHIELD), R68.1

Notes on the sheet:
USBSS: SSRXA/SSRXB 交叉连接 TXN/TXP SSTXA/SSTXB 交叉连接 TXN/TXP [非必要]将 R32_LINK_CFG 寄存器的 RB_LINK_SS_PLR_SWAP 置为1 [非必要]代码：USBSSD->LINK_CFG |= LINK_SS_PLR_SWAP; UHSIF: UHSIF_PORT_RM = 01 UHSIF_CLK_RM = 10

Board: 4 copper layers, 57.6 x 47.5 mm, 126 parts (0 on the bottom side), 146 nets.
