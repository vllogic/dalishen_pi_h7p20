# Repository vllogic/dalishen_pi_h7p20 (continued)

## KiCad design hardware/dalishen_pi_h7p20/dalishen_pi_h7p20.kicad_pcb (continued)

Parts:
C1, C3, C80: 1uF; C_0402_1005Metric
C2: 0.1uF; C_0402_1005Metric
J4: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_16P
R1, R2: 5.1k; R_0402_1005Metric
R3, R13: 10k,1%; R_0402_1005Metric
R12: 8.06k; R_0402_1005Metric
U2: USB3343; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm

Connections:
/USB334x_SP1/USB20_D_N: J4.A7 (D-), J4.B7 (D-), U2.14 (DM)
/USB334x_SP1/USB20_D_P: J4.A6 (D+), J4.B6 (D+), U2.13 (DP)
/USB334x_SP1/USB334x_26M: U2.21 (REFCLK/XI); also elsewhere on the board
/USB334x_SP1_CLK: U2.2 (CLKOUT); also elsewhere on the board
/USB334x_SP1_D0: U2.4 (DATA0); also elsewhere on the board
/USB334x_SP1_D1: U2.5 (DATA1); also elsewhere on the board
/USB334x_SP1_D2: U2.6 (DATA2); also elsewhere on the board
/USB334x_SP1_D3: U2.7 (DATA3); also elsewhere on the board
/USB334x_SP1_D4: U2.8 (DATA4); also elsewhere on the board
/USB334x_SP1_D5: U2.10 (DATA5); also elsewhere on the board
/USB334x_SP1_D6: U2.11 (DATA6); also elsewhere on the board
/USB334x_SP1_D7: U2.12 (DATA7); also elsewhere on the board
/USB334x_SP1_DIR: U2.1 (DIR); also elsewhere on the board
/USB334x_SP1_NXT: U2.3 (NXT); also elsewhere on the board
/USB334x_SP1_STP: U2.24 (STP); also elsewhere on the board
/VCC_3V3: C1.2, C2.2, R13.1, U2.9 (VDDIO), U2.16 (VBAT); also elsewhere on the board
/VCC_5V: J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), R3.1; also elsewhere on the board
GND: C1.1, C2.1, C3.1, C80.1, J4.A1 (GND), J4.A8 (SBU1), J4.A12 (GND), J4.B1 (GND), J4.B8 (SBU2), J4.B12 (GND), J4.S1 (SHIELD), R1.2, R2.2, R12.2, U2.25 (GND); also elsewhere on the board
unnamed: J4.A5 (CC1), R2.1
unnamed: J4.B5 (CC2), R1.1
unnamed: C80.2, U2.15 (VDD33), U2.18 (ID)
unnamed: R12.1, U2.19 (RBIAS)
unnamed: R3.2, U2.17 (VBUS)
unnamed: C3.2, U2.23 (VDD18)
unnamed: R13.2, U2.22 (~RESETB)

Parts of its further copies:
C81, C83, C84: 1uF; C_0402_1005Metric
C82: 0.1uF; C_0402_1005Metric
J8: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_16P
R16, R17: 5.1k; R_0402_1005Metric
R23, R26: 10k,1%; R_0402_1005Metric
R25: 8.06k; R_0402_1005Metric
U10: USB3343; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm

Connections of its further copies:
/USB334x_SP2/USB20_D_N: J8.A7 (D-), J8.B7 (D-), U10.14 (DM)
/USB334x_SP2/USB20_D_P: J8.A6 (D+), J8.B6 (D+), U10.13 (DP)
/USB334x_SP2/USB334x_26M: U10.21 (REFCLK/XI); also elsewhere on the board
/USB334x_SP2_CLK: U10.2 (CLKOUT); also elsewhere on the board
/USB334x_SP2_D0: U10.4 (DATA0); also elsewhere on the board
/USB334x_SP2_D1: U10.5 (DATA1); also elsewhere on the board
/USB334x_SP2_D2: U10.6 (DATA2); also elsewhere on the board
/USB334x_SP2_D3: U10.7 (DATA3); also elsewhere on the board
/USB334x_SP2_D4: U10.8 (DATA4); also elsewhere on the board
/USB334x_SP2_D5: U10.10 (DATA5); also elsewhere on the board
/USB334x_SP2_D6: U10.11 (DATA6); also elsewhere on the board
/USB334x_SP2_D7: U10.12 (DATA7); also elsewhere on the board
/USB334x_SP2_DIR: U10.1 (DIR); also elsewhere on the board
/USB334x_SP2_NXT: U10.3 (NXT); also elsewhere on the board
/USB334x_SP2_STP: U10.24 (STP); also elsewhere on the board
/VCC_3V3: C81.2, C82.2, R26.1, U10.9 (VDDIO), U10.16 (VBAT); also elsewhere on the board
/VCC_5V: J8.A4 (VBUS), J8.A9 (VBUS), J8.B4 (VBUS), J8.B9 (VBUS), R23.1; also elsewhere on the board
GND: C81.1, C82.1, C83.1, C84.1, J8.A1 (GND), J8.A8 (SBU1), J8.A12 (GND), J8.B1 (GND), J8.B8 (SBU2), J8.B12 (GND), J8.S1 (SHIELD), R16.2, R17.2, R25.2, U10.25 (GND); also elsewhere on the board
unnamed: J8.A5 (CC1), R17.1
unnamed: J8.B5 (CC2), R16.1
unnamed: C84.2, U10.15 (VDD33), U10.18 (ID)
unnamed: R25.1, U10.19 (RBIAS)
unnamed: R23.2, U10.17 (VBUS)
unnamed: C83.2, U10.23 (VDD18)
unnamed: R26.2, U10.22 (~RESETB)

Parts:
C12, C14: 4.3pF; C_0402_6mil
C13, C49, C50: 1uF; C_0402_1005Metric
C15: 0.1uF; C_0402_1005Metric
D5: LED_RED; LED_0603_1608Metric
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_16P
J3: USB_A; USB_AF_SMT
R4: 0; R_0402_1005Metric
R7, R79, R90: 10k,1%; R_0402_1005Metric
R76, R77: 5.1k; R_0402_1005Metric
R78: 1M; R_0402_1005Metric
R89: 8.06k; R_0402_1005Metric
SW6: SW_DPDT_x2
U20: USB3343; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
Y1: 26M; OSC_2016

Connections:
/USB334x/T_VBUS: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), J3.1 (VBUS), R79.1, SW6.3 (C)
/USB334x/USB20_D_N: J2.A7 (D-), J2.B7 (D-), J3.2 (D-), U20.14 (DM)
/USB334x/USB20_D_P: J2.A6 (D+), J2.B6 (D+), J3.3 (D+), U20.13 (DP)
/USB334x_CLK: U20.2 (CLKOUT); also elsewhere on the board
/USB334x_D0: U20.4 (DATA0); also elsewhere on the board
/USB334x_D1: U20.5 (DATA1); also elsewhere on the board
/USB334x_D2: U20.6 (DATA2); also elsewhere on the board
/USB334x_D3: U20.7 (DATA3); also elsewhere on the board
/USB334x_D4: U20.8 (DATA4); also elsewhere on the board
/USB334x_D5: U20.10 (DATA5); also elsewhere on the board
/USB334x_D6: U20.11 (DATA6); also elsewhere on the board
/USB334x_D7: U20.12 (DATA7); also elsewhere on the board
/USB334x_DIR: U20.1 (DIR); also elsewhere on the board
/USB334x_NXT: U20.3 (NXT); also elsewhere on the board
/USB334x_STP: U20.24 (STP); also elsewhere on the board
/VCC_3V3: C13.2, C15.2, R90.1, U20.9 (VDDIO), U20.16 (VBAT); also elsewhere on the board
GND: C12.1, C13.1, C14.1, C15.1, C49.1, C50.1, D5.1 (K), J2.A1 (GND), J2.A8 (SBU1), J2.A12 (GND), J2.B1 (GND), J2.B8 (SBU2), J2.B12 (GND), J2.S1 (SHIELD), J3.4 (GND), J3.5 (Shield), R76.2, R77.2, R89.2, U20.25 (GND), Y1.2, Y1.4; also elsewhere on the board
unnamed: D5.2 (A), R7.1
unnamed: J2.A5 (CC1), R77.1
unnamed: J2.B5 (CC2), R76.1
unnamed: SW6.2 (B), SW6.5 (B)
unnamed: R7.2, SW6.6 (C)
unnamed: R4.2, U20.18 (ID)
unnamed: R89.1, U20.19 (RBIAS)
unnamed: C14.2, R78.2, U20.21 (REFCLK/XI), Y1.3
unnamed: R79.2, U20.17 (VBUS)
unnamed: C49.2, U20.23 (VDD18)
unnamed: C50.2, R4.1, U20.15 (VDD33)
unnamed: C12.2, R78.1, U20.20 (XO), Y1.1
unnamed: R90.2, U20.22 (~RESETB)

Board: 4 copper layers, 92.0 x 71.0 mm, 249 parts (15 on the bottom side), 234 nets.

File hardware/dalishen_pi_h7p20/production_files.20250820/BOM-dalishen_pi_h7p20.csv:

Comment,Designator,Footprint,LCSC,Quantity
10uF,C30,C_0402_1005Metric,,1
47k,R1003,R_0402_1005Metric,,1
NC,R7,R_0402_1005Metric,,1
33,R86,R_0402_1005Metric,,1
SW_DIP_x03,SW3,SW_DIP_SPSTx03_Slide_6.7x9.18mm_W8.61mm_P2.54mm_LowProfile,,1
2.49k,R16,R_0402_1005Metric,,1
2.49k,R55,R_0402_1005Metric,,1
0.1uF,C52,C_0402_1005Metric,,1
0R,C78,C_0402_1005Metric,,1
1.5uH,L4,L_NR2520xx,,1
0.1uF,C10,C_0402_1005Metric,,1
0.1uF,C21,C_0402_1005Metric,,1
4.7k,R41,R_0402_1005Metric,,1
33,R75,R_0402_1005Metric,,1
LED_GREEN,D3,LED_0603_1608Metric,,1
0.1uF,C20,C_0402_1005Metric,,1
NC,C79,C_0402_1005Metric,,1
"10k,1%",R5,R_0402_1005Metric,,1
10uF,C47,C_0402_1005Metric,,1
5.1k,R1002,R_0402_1005Metric,,1
XC6206-2.8,U5,SOT-23,,1
0R,L1001,L_0402_1005Metric,,1
5.1k,R69,R_0402_1005Metric,,1
33,R8,R_0402_1005Metric,,1
1uF,C13,C_0402_1005Metric,,1
1uF,C34,C_0402_1005Metric,,1
RJ45_HR911130A,J10,RJ45_HR911130A,,1
33,R9,R_0402_1005Metric,,1
SW_Push,SW2,SW-3x6mm_Hxx_SMD,,1
10uF,C68,C_0402_1005Metric,,1
1uF,C71,C_0402_1005Metric,,1
5.1k,R21,R_0402_1005Metric,,1
10uH,L1,L_NR3015,,1
Conn_02x05_Odd_Even,J1,PinHeader_2x05_P1.27mm_Vertical_SMD,,1
0.1uF,C6,C_0402_1005Metric,,1
1uF,C73,C_0402_1005Metric,,1
"20k,1%",R29,R_0402_1005Metric,,1
0.1uF,C64,C_0402_1005Metric,,1
OV5640,J7,Hirose_FH12-24S-0.5SH_1x24-1MP_P0.50mm_Horizontal,,1
NC,X1,OSC_3225,,1
0.1uF,C11,C_0402_1005Metric,,1
220pF,C28,C_0402_1005Metric,,1
1uF,C50,C_0402_1005Metric,,1
YT8531C,U1,QFN-40-1EP_5x5mm_P0.4mm_EP3.6x3.6mm,,1
1uF,C1012,C_0402_6mil,,1
1.5uH,L3,L_NR2520xx,,1
0.1uF,C48,C_0402_1005Metric,,1
NC,R52,R_0402_1005Metric,,1
8.06k,R89,R_0402_1005Metric,,1
XC6206-1.5,U8,SOT-23,,1
2.49k,R56,R_0402_1005Metric,,1
33,R74,R_0402_1005Metric,,1
4.3pF,C14,C_0402_6mil,,1
5.1k,R1001,R_0402_1005Metric,,1
0,R6,R_0402_1005Metric,,1
"10,1%",R65,R_0402_1005Metric,,1
Antenna_Shield,AE1001,Texas_SWRA117D_2.4GHz_Left,,1
0.1uF,C9,C_0402_1005Metric,,1
5.1k,R62,R_0402_1005Metric,,1
5.1k,R54,R_0402_1005Metric,,1
USB_C_Receptacle_USB2.0_16P,J2,USB_C_Receptacle_16P,,1
33,R70,R_0402_1005Metric,,1
USB_C_Receptacle_USB2.0_16P,J1001,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,,1
5.1k,R68,R_0402_1005Metric,,1
10k,R80,R_0402_1005Metric,,1
10uF,C4,C_0402_1005Metric,,1
5.1k,R40,R_0402_1005Metric,,1
1N5819(S4),D8,D_SOD-323_BAT60,,1
10uF,C27,C_0402_1005Metric,,1
"4.7uH,MPL2012S4R7MHT",L2,L_0805_2012Metric,,1
"33k,1%",R30,R_0402_1005Metric,,1
5.1k,R48,R_0402_1005Metric,,1
10uF,C31,C_0402_1005Metric,,1
NC,C1002,C_0402_1005Metric,,1
1uF,C40,C_0402_1005Metric,,1
5.1k,R43,R_0402_1005Metric,,1
10uF,C37,C_0402_1005Metric,,1
0.1uF,C18,C_0402_1005Metric,,1
10uF,C33,C_0402_1005Metric,,1
33,R87,R_0402_1005Metric,,1
Conn_02x10_Odd_Even,CY_J2,PinSocket_2x10_P2.54mm_Vertical,,1
33,R83,R_0402_1005Metric,,1
1uF,C70,C_0402_1005Metric,,1
5.1k,R77,R_0402_1005Metric,,1
0.1uF,C66,C_0402_1005Metric,,1
NC,C1011,C_0402_6mil,,1
5.1k,R61,R_0402_1005Metric,,1
33,R85,R_0402_1005Metric,,1
26M,Y1,OSC_2016,,1
SW_Push,SW4,SW-3x6mm_Hxx_SMD,,1
1uF,C1008,C_0402_1005Metric,,1
10uF,C41,C_0402_1005Metric,,1
SY7201ABC,U4,SOT-23-6,,1
5.1k,R50,R_0402_1005Metric,,1
0.1uF,C63,C_0402_1005Metric,,1
0.1uF,C59,C_0402_1005Metric,,1
5.1k,R20,R_0402_1005Metric,,1
0.1uF,C42,C_0402_1005Metric,,1
0.1uF,C23,C_0402_1005Metric,,1
NC,Y2,OSC_3225,,1
220pF,C25,C_0402_1005Metric,,1
1uF,C16,C_0402_1005Metric,,1
H7P20N0L128-M3H1,U3,LQFP-128_14x14mm_P0.4mm_pad,,1
"33k,1%",R36,R_0402_1005Metric,,1
5.1k,R42,R_0402_1005Metric,,1
5.1k,R18,R_0402_1005Metric,,1
TestPoint,TP1,PinHeader_1x01_P1.00mm_Vertical,,1
0.1uF,C19,C_0402_1005Metric,,1
0.1uF,C43,C_0402_1005Metric,,1
"26M, 10PPM",Y1001,OSC_2016,,1
33,R11,R_0402_1005Metric,,1
2.49k,R38,R_0402_1005Metric,,1
LED_YELLOW,D4,LED_0603_1608Metric,,1
10uF,C57,C_0402_1005Metric,,1
10uF,C1009,C_0402_1005Metric,,1
4.3pF,C12,C_0402_6mil,,1
10uF,C58,C_0402_1005Metric,,1
4.3pF,C1003,C_0402_1005Metric,,1
10uF,C32,C_0402_1005Metric,,1
5.1k,R47,R_0402_1005Metric,,1
10uF,C1005,C_0402_1005Metric,,1
0R,L1003,L_0402_1005Metric,,1
AIC8800FC,U1001,QFN-36-1EP_4x4mm_P0.35mm_EP2.5x2.5mm,,1
220pF,C35,C_0402_1005Metric,,1
0.1uF,C62,C_0402_1005Metric,,1
"33k,1%",R34,R_0402_1005Metric,,1
33,R71,R_0402_1005Metric,,1
33,R72,R_0402_1005Metric,,1
P25Q80H/P25Q64H/P25Q128HA,U1002,USON-8-1EP_3x2mm_P0.5mm_EP1.6x02mm,,1
CJ3439KDW,U9,SOT-363_SC-70-6,,1
1uF,C75,C_0402_1005Metric,,1
2.49k,R39,R_0402_1005Metric,,1
"10k,1%",R79,R_0402_1005Metric,,1
0.1uF,C7,C_0402_1005Metric,,1
10uF,C1010,C_0402_6mil,,1
1.5uH,L5,L_NR2520xx,,1
"10,1%",R64,R_0402_1005Metric,,1
"4.7uH,MPL2012S4R7MHT",L1004,L_0805_2012Metric,,1
5.1k,R49,R_0402_1005Metric,,1
"20k,1%",R35,R_0402_1005Metric,,1
1uF,C46,C_0402_1005Metric,,1
0.1uF,C45,C_0402_1005Metric,,1
USB_A,J3,USB-AF_YIJIAN,,1
2.49k,R57,R_0402_1005Metric,,1
0.1uF,C53,C_0402_1005Metric,,1
0.1uF,C15,C_0402_1005Metric,,1
USB3343,U20,QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm,,1
0.1uF,C17,C_0402_1005Metric,,1
"10k,1%",R15,R_0402_1005Metric,,1
5.1k,R76,R_0402_1005Metric,,1
10uF,C24,C_0402_1005Metric,,1
0.1uF,C5,C_0402_1005Metric,,1
"1uF,50V",C69,C_0603_1608Metric,,1
10uF,C26,C_0402_1005Metric,,1
"10k,1%",R44,R_0402_1005Metric,,1
"10k,1%",R90,R_0402_1005Metric,,1
10k,R63,R_0402_1005Metric,,1
SW_Push,SW1,SW-3x6mm_Hxx_SMD,,1
P25Q64SH-SSH-IR,U7,SOIC-8_P1.27mm_Common,,1
10uF,C44,C_0402_1005Metric,,1
Conn_02x10_Odd_Even,CY_J1,PinSocket_2x10_P2.54mm_Vertical,,1
1uF,C39,C_0402_1005Metric,,1
TestPoint,TP2,PinHeader_1x01_P1.00mm_Vertical,,1
1uF,C49,C_0402_1005Metric,,1
1uF,C77,C_0402_1005Metric,,1
NC,R53,R_0402_1005Metric,,1
0.1uF,C55,C_0402_1005Metric,,1
5.1k,R22,R_0402_1005Metric,,1
0.1uF,C8,C_0402_1005Metric,,1
10uF,C38,C_0402_1005Metric,,1
1uF,C76,C_0402_1005Metric,,1
1uF,C1007,C_0402_1005Metric,,1
4.3pF,C1006,C_0402_1005Metric,,1
"20k,1%",R31,R_0402_1005Metric,,1
0.1uF,C60,C_0402_1005Metric,,1
0.1uF,C22,C_0402_1005Metric,,1
NC,R51,R_0402_1005Metric,,1
0.1uF,C61,C_0402_1005Metric,,1
1uF,C72,C_0402_1005Metric,,1
33,R91,R_0402_1005Metric,,1
0.1uF,C54,C_0402_1005Metric,,1
"150k,1%",R33,R_0402_1005Metric,,1
5V,J6,PinSocket_1x01_P2.54mm_Vertical,,1
1M,R78,R_0402_1005Metric,,1
D500C930SV0,J9,Hirose_FH12-40S-0.5SH_1x40-1MP_P0.50mm_Horizontal,,1
0.1uF,C65,C_0402_1005Metric,,1
0.1uF,C67,C_0402_1005Metric,,1
NC,2x5_2.54.1001,IDC-Header_2x05_P2.54mm_Vertical,,1
5.1k,R46,R_0402_1005Metric,,1
SW_Push,SW5,SW-3x6mm_Hxx_SMD,,1
33,R84,R_0402_1005Metric,,1
33,R73,R_0402_1005Metric,,1
0,R4,R_0402_1005Metric,,1
10uF,C29,C_0402_1005Metric,,1
LED_RED,D1,LED_0603_1608Metric,,1
10k,R81,R_0402_1005Metric,,1
2.49k,R45,R_0402_1005Metric,,1
0.1uF,C56,C_0402_1005Metric,,1
1uF,C1013,C_0402_6mil,,1
NC,C2,C_0402_1005Metric,,1
EA3036C,U6,QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm,,1
0.1uF,C51,C_0402_1005Metric,,1
10k,R82,R_0402_1005Metric,,1
0.1uF,C74,C_0402_1005Metric,,1
"10k,1%",R32,R_0402_1005Metric,,1
10uF,C36,C_0402_1005Metric,,1
LED_BLUE,D2,LED_0603_1608Metric,,1
"10k,1%",R19,R_0402_1005Metric,,1
SolderJumper_2_Bridged,JP2,SolderJumper-2_P1.3mm_Bridged2Bar_RoundedPad1.0x1.5mm,,1
SolderJumper_2_Bridged,JP6,SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm,,1
SolderJumper_2_Bridged,JP4,SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm,,1
SolderJumper_2_Bridged,JP7,SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm,,1
TestPoint,TP1005,TestPoint_Pad_D0.75mm,,1
TestPoint,TP1006,TestPoint_Pad_D0.75mm,,1
TestPoint,TP1001,TestPoint_Pad_D0.75mm,,1
SolderJumper_2_Bridged,JP5,SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm,,1
TestPoint,TP1007,TestPoint_Pad_D0.75mm,,1
SolderJumper_2_Bridged,JP3,SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm,,1
SolderJumper_2_Bridged,JP8,SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm,,1
SolderJumper_2_Bridged,JP9,SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm,,1
TestPoint,TP1003,TestPoint_Pad_D0.75mm,,1
TestPoint,TP1002,TestPoint_Pad_D0.75mm,,1
TestPoint,TP1004,TestPoint_Pad_D0.75mm,,1

## KiCad design hardware/usb_sniffer_h7p20/usb_sniffer_h7p20.kicad_pcb

Parts:
C2, C11: 1uF; C_0402_1005Metric
C4, C14, C15, C16, C18, C28, C29, C33, C34, C35, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C55, C57, C58, C59, C60, C61: 0.1uF; C_0402_1005Metric
C12, C13, C27, C62: 10uF; C_0402_1005Metric
C19, C54, C56: NC; C_0402_1005Metric
C31, C32: 12pF; C_0402_1005Metric
D1: CESD5V0D5; D_SOD-523
D3: LED_ABGR; LED_RGB_Everlight_EASV3015RGBA0_Horizontal
F1: SMD0805B100TFT; Fuse_0805_2012Metric
J1: FPGA_JTAG; PinHeader_1x05_P2.54mm_Vertical
J4: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_16P
J5: FFC-40P-0.5mm,NC; TE_4-1734839-0_1x40-1MP_P0.5mm_Horizontal
J6: Trigger; PinHeader_1x02_P2.54mm_Vertical
JP2: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP3, JP4: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R2, R3, R4, R13, R18: 5.1k,1%; R_0402_1005Metric
R5, R6, R12, R19, R24: 10k,1%; R_0402_1005Metric
R7: 470; R_0402_1005Metric
R8, R9: 4.7k,1%; R_0402_1005Metric
R15, R16, R17: 4.7k; R_0402_1005Metric
TP1, TP2, TP3, TP4, TP14, TP15: TestPoint; PinHeader_1x01_P1.00mm_Vertical
TP5, TP6, TP16, TP17, TP18, TP20, TP21: TestPoint; TestPoint_Pad_D0.3mm
TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP19: TestPoint; TestPoint_Pad_D0.75mm
U1: H7P20N0L128-M3H1; LQFP-128_14x14mm_P0.4mm_pad
U6: P25Q64SH-SSH-IR; SOP-8_3.9x4.9mm_P1.27mm
U7: CY7C68013A-56LTX; QFN-56-1EP_8x8mm_P0.5mm_EP4.5x5.2mm
U8: 24C32; SOP-8_3.9x4.9mm_P1.27mm
U9: CJ3439KDW; SOT-363_SC-70-6
Y2: 24M; OSC_3225

Connections:
/B9_IO2N: J5.24, U1.51 (IO2N_9)
/B9_IO2P: J5.23, U1.52 (IO2P_9)
/B9_IO4N: J5.21, U1.54 (IO4N_9)
/B9_IO4P: J5.20, U1.55 (IO4P_PCLK_9)
/B9_IO6N: J5.18, U1.56 (IO6N_9)
/B9_IO6P: J5.17, U1.57 (IO6P_9)
/B9_IO9N: J5.15, U1.60 (IO9N_9)
/B9_IO9P: J5.14, U1.61 (IO9P_PCLK_9)
/B9_IO12N: J5.12, U1.63 (IO12N_9)
/B9_IO12P: J5.11, U1.64 (IO12P_9)
/B10_IO2N: J5.39, U1.37 (IO2N_10)
/B10_IO2P: J5.38, U1.38 (IO2P_10)
/B10_IO4N: J5.36, U1.40 (IO4N_10)
/B10_IO4P: J5.35, U1.41 (IO4P_PCLK_10)
/B10_IO6N: J5.33, U1.42 (IO6N_10)
/B10_IO6P: J5.32, U1.43 (IO6P_10)
/B10_IO9N: J5.30, U1.46 (IO9N_10)
/B10_IO9P: J5.29, U1.47 (IO9P_PCLK_10)
/B10_IO12N: J5.27, U1.49 (IO12N_10)
/B10_IO12P: J5.26, U1.50 (IO12P_10)
/Boot: R15.1, TP15.1, U8.2 (A1)
/CRST_N: C2.2, R13.2, TP1.1, TP8.1, U1.114 (CRSTN)
/CY_CLKOUT: U1.6 (IO13_PCLK_8), U7.54 (CLKOUT)
/CY_FD_0: U1.13 (IO21_8), U7.18 (PB0/FD0)
/CY_FD_1: U1.14 (IO22_8), U7.19 (PB1/FD1)
/CY_FD_2: U1.15 (IO1_7), U7.20 (PB2/FD2)
/CY_FD_3: U1.16 (IO2_7), U7.21 (PB3/FD3)
/CY_FD_4: U1.18 (IO5_7), U7.22 (PB4/FD4)
/CY_FD_5: U1.19 (IO6_7), U7.23 (PB5/FD5)
/CY_FD_6: U1.20 (IO9_7), U7.24 (PB6/FD6)
/CY_FD_7: U1.21 (IO10_7), U7.25 (PB7/FD7)
/CY_FD_8: U1.74 (IO13_GCLK_4), U7.45 (PD0/FD8)
/CY_FD_9: U1.75 (IO15_4), U7.46 (PD1/FD9)
/CY_FD_10: U1.76 (IO16_4), U7.47 (PD2/FD10)
/CY_FD_11: U1.77 (IO19_4), U7.48 (PD3/FD11)
/CY_FD_12: U1.78 (IO20_4), U7.49 (PD4/FD12)
/CY_FD_13: U1.80 (IO23_4), U7.50 (PD5/FD13)
/CY_FD_14: U1.81 (IO24_4), U7.51 (PD6/FD14)
/CY_FD_15: U1.82 (IO3_3), U7.52 (PD7/FD15)
/CY_FIOADDR0: U1.10 (IO19_8), U7.37 (PA4/FIOADDR0)
/CY_FIOADDR1: U1.11 (IO20_8), U7.38 (PA5/FIOADDR1)
/CY_FLAGA: U1.22 (IO12_GCLK_7), U7.29 (CTL0/FLAGA)
/CY_FLAGB: U1.23 (IO13_PCLK_7), U7.30 (CTL1/FLAGB)
/CY_FLAGC: U1.24 (IO15_7), U7.31 (CTL2/FLAGC)
/CY_FLAGD: U1.73 (IO12_PCLK_4), U7.40 (PA7/FLAGD/~SLCS)
/CY_IFCLK: U1.5 (IO12_GCLK_8), U7.13 (IFCLK)
/CY_INT0: U1.4 (IO11_8), U7.33 (PA0/~INT0)
/CY_INT1: U1.8 (IO17_8), U7.34 (PA1/~INT1)
/CY_PKTEND: U1.72 (IO10_4), U7.39 (PA6/PKTEND)
/CY_SCL: R17.2, U7.15 (SCL), U8.6 (SCL)
/CY_SDA: R16.2, U7.16 (SDA), U8.5 (SDA)
/CY_SLOE: U1.25 (IO16_7), U7.35 (PA2/SLOE)
/CY_SLRD: U1.126 (IO3_8), U7.1 (RDY0/SLRD)
/CY_SLWR: U1.127 (IO4_8), U7.2 (RDY1/SLWR)
/CY_WU2: U1.9 (IO18_8), U7.36 (PA3/WU2)
/FPGA_CDONE: D3.1 (A), TP18.1, U1.105 (IO26_CDONE_2)
/FPGA_FLASH_CLK: U1.116 (IO18_PCCLK_1), U6.6 (CLK)
/FPGA_FLASH_CS: R5.2, U1.118 (IO12_CSN_1), U6.1 (~CS)
/FPGA_FLASH_MISO: U1.115 (IO19_MISO1_1), U6.2 (DO(IO1))
/FPGA_FLASH_MOSI: U1.119 (IO11_MOSI0_1), U6.5 (DI(IO0))
/FPGA_MSEL0: JP2.1 (A), U1.122 (IO10_MSEL0_1)
/FPGA_MSEL1: JP3.1 (A), U1.124 (IO4_MSEL1_1)
/FPGA_MSEL2: JP4.1 (A), U1.125 (IO2_MSEL2_1)
/FPGA_OUT_26M: U1.104 (IO27_GCLK_2); also elsewhere on the board
/FPGA_TCK: J1.2, TP10.1, U1.112 (IO21_TCK_1)
/FPGA_TDI: J1.3, TP9.1, U1.113 (IO20_TDI_1)
/FPGA_TDO: J1.5, TP12.1, U1.109 (IO23_TDO_1)
/FPGA_TMS: J1.4, TP11.1, U1.110 (IO22_TMS_1)
/IN: R7.1, U1.91 (IO12_PCLK_3)
/LED_BLUE: R9.2, U1.28 (IO17_7)
/LED_GREEN: R12.2, U1.29 (IO18_7)
/LED_RED: R8.2, U1.31 (IO21_7)
/USB20_DM_CMP1: U1.68 (IO7_4); also elsewhere on the board
/USB20_DM_CMP2: U1.69 (IO8_4); also elsewhere on the board
/USB20_DM_CMP3: U1.108 (IO24_GCLK_1); also elsewhere on the board
/USB20_DP_CMP1: U1.71 (IO9_4); also elsewhere on the board
/USB20_DP_CMP2: U1.102 (IO33_MISO3_2); also elsewhere on the board
/USB20_DP_CMP3: U1.106 (IO25_GCLK_2); also elsewhere on the board
/USB334x_CLK: U1.92 (IO13_GCLK_3); also elsewhere on the board
/USB334x_D0: U1.94 (IO18_3); also elsewhere on the board
/USB334x_D1: U1.96 (IO20_3); also elsewhere on the board
/USB334x_D2: U1.95 (IO19_3); also elsewhere on the board
/USB334x_D3: U1.90 (IO10_3); also elsewhere on the board
/USB334x_D4: U1.89 (IO9_3); also elsewhere on the board
/USB334x_D5: U1.86 (IO7_3); also elsewhere on the board
/USB334x_D6: U1.85 (IO6_3); also elsewhere on the board
/USB334x_D7: U1.83 (IO4_3); also elsewhere on the board
/USB334x_DIR: U1.98 (IO23_3); also elsewhere on the board
/USB334x_NXT: U1.93 (IO17_3); also elsewhere on the board
/USB334x_STP: U1.99 (IO24_3); also elsewhere on the board
/USB_D_N: J4.A7 (D-), J4.B7 (D-), U7.9 (D-)
/USB_D_P: J4.A6 (D+), J4.B6 (D+), U7.8 (D+)
/VCCAUX: C13.2, C16.2, C41.2, C44.2, C50.2, C60.2, J5.7, J5.8, R24.2, U1.27 (VDDAUX), U1.44 (VDDAUX), U1.58 (VDDAUX), U1.87 (VDDAUX), U1.120 (VDDAUX), U9.4 (S2); also elsewhere on the board
/VCC_3V3: C4.2, C11.2, C14.2, C18.2, C27.2, C28.2, C29.2, C33.2, C34.2, C42.2, C45.2, C48.2, C51.2, J5.4, J5.5, JP2.2 (B), JP3.2 (B), JP4.2 (B), R4.1, R5.1, R6.1, R13.1, R16.1, R17.1, R18.1, R19.1, TP14.1, TP19.1, U1.12 (VDDIO_8), U1.17 (VDDIO_7), U1.30 (VDDIO_7), U1.67 (VDDIO_4), U1.79 (VDDIO_4), U1.84 (VDDIO_3), U1.97 (VDDIO_3), U1.103 (VDDIO_2), U1.111 (VDDIO_1), U1.123 (VDDIO_1), U1.128 (VDDIO_8), U6.8 (VCC), U7.3 (AVCC), U7.7 (AVCC), U7.11 (VCC), U7.17 (VCC), U7.27 (VCC), U7.32 (VCC), U7.43 (VCC), U7.55 (VCC), U8.1 (A0), U8.8 (VCC), U9.2 (G1); also elsewhere on the board
/VCC_5V: D1.1 (K), F1.1, J5.1, J5.2, TP13.1; also elsewhere on the board
/VDDIO_1V8: C47.2, C53.2, C58.2, C62.2, U1.33 (VDDIO_18), U1.35 (VDDIO_18), U1.39 (VDDIO_10), U1.48 (VDDIO_10), U1.53 (VDDIO_9), U1.62 (VDDIO_9), U9.3 (D2)
/VDD_CORE: C12.2, C15.2, C19.2, C43.2, C46.2, C49.2, C52.2, C54.2, C55.2, C56.2, C57.2, C59.2, C61.2, U1.7 (VDD_CORE), U1.26 (VDD_CORE), U1.36 (VDD_CORE), U1.45 (VDD_CORE), U1.59 (VDD_CORE), U1.70 (VDD_CORE), U1.88 (VDD_CORE), U1.100 (VDD_CORE), U1.121 (VDD_CORE); also elsewhere on the board
GND: C2.1, C4.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C18.1, C19.1, C27.1, C28.1, C29.1, C31.1, C32.1, C33.1, C34.1, C35.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, C61.1, C62.1, D1.2 (A), J1.1, J4.A1 (GND), J4.A8 (SBU1), J4.A12 (GND), J4.B1 (GND), J4.B8 (SBU2), J4.B12 (GND), J4.S1 (SHIELD), J5.10, J5.13, J5.16, J5.19, J5.22, J5.25, J5.28, J5.31, J5.34, J5.37, J5.40, J6.2, R2.1, R3.1, R15.2, TP2.1, TP3.1, TP7.1, U1.34 (GND), U1.107 (MSC), U1.129 (GND), U6.4 (GND), U6.9 (EP), U7.6 (AGND), U7.10 (AGND), U7.12 (GND), U7.14 (RESERVED), U7.26 (GND), U7.28 (GND), U7.41 (GND), U7.53 (GND), U7.56 (GND), U7.57 (EP), U8.3 (A2), U8.4 (GND), U8.7 (WP), U9.1 (S1), Y2.2, Y2.4; also elsewhere on the board
unnamed: D3.2 (BK), R9.1
unnamed: D3.3 (GK), R12.1
unnamed: D3.4 (RK), R8.1
unnamed: F1.2, J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS)
unnamed: J4.A5 (CC1), R2.2
unnamed: J4.B5 (CC2), R3.2
unnamed: J6.1, R7.2
unnamed: TP21.1, U1.65 (IO1_4)
unnamed: TP20.1, U1.66 (IO2_4)
unnamed: TP16.1, U1.1 (IO6_8)
unnamed: TP17.1, U1.117 (IO16_GCLK_1)
unnamed: TP5.1, U1.32 (IO22_7)
unnamed: TP6.1, U1.101 (IO34_MISO2_2)
unnamed: R6.2, U6.3 (IO2)
unnamed: R19.2, U6.7 (IO3)
unnamed: R18.2, U7.44 (WAKEUP)
unnamed: C31.2, U7.5 (XTALIN), Y2.1
unnamed: C32.2, U7.4 (XTALOUT), Y2.3
unnamed: C35.2, R4.2, TP4.1, U7.42 (~RESET)
unnamed: R24.1, U9.5 (G2), U9.6 (D1)

Notes on the sheet:
CJ3439KDW原理示意图
GND TCK TDI TMS TDO
上电顺序：VCC_5V --- 0R >>> OUT1(0.95V) --- 10k 1uF RC >>> OUT2(VCCAUX) --- 20k 1uF RC >>> OUT3(3.3V) CJ3439KDW在3.3V上电后，导通VCCAUX到VDDIO_1V8

Parts:
C17, C20, C22, C24, C25, C37, C39: 10uF; C_0402_1005Metric
C21, C23, C30: 220pF; C_0402_1005Metric
C26, C36, C38: 1uF; C_0402_1005Metric
L2, L3: 4.7uH,MPL2012S4R7MHT; L_0805_2012Metric
L5: 1.5uH; L_NR2520xx
R32: 150k,1%; R_0402_1005Metric
R33, R38, R39: 33k,1%; R_0402_1005Metric
R34: 10k,1%; R_0402_1005Metric
R35, R37, R40: 20k,1%; R_0402_1005Metric
U11: EA3036C; QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm

Connections:
/ET3036C/EA3036_EN2: C38.2, R37.1, U11.8 (EN2)
/ET3036C/EA3036_EN3: C36.2, R38.1, U11.18 (EN3)
/VCCAUX: C17.2, C23.1, L3.1, R35.2; also elsewhere on the board
/VCC_3V3: C20.2, C21.2, L2.1, R32.1; also elsewhere on the board
/VCC_5V: C22.2, C24.2, C25.2, C26.2, R37.2, R38.2, U11.7 (VIN2), U11.9 (EN1), U11.10 (VIN1), U11.16 (VCC), U11.19 (VIN3); also elsewhere on the board
/VDD_CORE: C30.1, C37.2, C39.2, L5.2, R40.2; also elsewhere on the board
GND: C17.1, C20.1, C22.1, C24.1, C25.1, C26.1, C36.1, C37.1, C38.1, C39.1, R33.2, R34.1, R39.1, U11.1 (GND3), U11.4 (GND2), U11.5 (GND2), U11.12 (GND1), U11.13 (GND1), U11.15 (AGND), U11.17 (AGND), U11.21 (EPAD); also elsewhere on the board
unnamed: C30.2, R39.2, R40.1, U11.14 (FB1)
unnamed: C23.2, R34.2, R35.1, U11.3 (FB2)
unnamed: C21.1, R32.2, R33.1, U11.2 (FB3)
unnamed: L5.1, U11.11 (LX1)
unnamed: L3.2, U11.6 (LX2)
unnamed: L2.2, U11.20 (LX3)
